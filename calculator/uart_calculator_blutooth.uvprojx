# Keil uVision project uart_calculator_blutooth.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_calculator_blutooth
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\app;.\hal;.\lib;.\mcal
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: app.h lcdapps.c lcdapps.h source.c
    ./: uart_calculator_blutooth.uvoptx
  group hal
    ./hal/: keypad.c keypad.h lcd.c lcd.h lcdconfig.h rgb.c rgb.h switch.c switch.h
  group mcal
    ./mcal/: clock.c clock.h NVIC.c NVIC.h pwm.c pwm.h ssi.c ssi.h systick.c systick.h TM4C123GH6PM.h tm4c123io.c tm4c123io.h twi.c twi.h uart.c uart.h
  group lib
    ./lib/: bitManip.h math.c math.h stdint.h strfuncs.c strfuncs.h array.c array.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
